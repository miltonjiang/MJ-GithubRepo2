# IAR project Light Effects.ewp, settings and files
configuration CRC16 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429II ST STM32F429II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F429X; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ; app\; modules\; board\; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32f429xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CRC32_Static (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: stm32f429xI_CRC32_Static.icf
configuration CRC32_Dynamic (ARM, debug)
  as the first configuration, except:
  postbuild: ielftool --fill 0xFF;__checksum_begin-__checksum_end --checksum __checksum:4,crc32:Li,0xffffffff;__checksum_begin-__checksum_end+3 --verbose "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkIcfFile: stm32f429xI_CRC32_Dynamic.icf
  group app
    app/: Checksum_CRC16.c Checksum_CRC32_Dynamic.c Checksum_CRC32_Static.c main.c stm32f4xx_it.c
  group board
    board/: iar_stm32f429ii_aca.c
  group startup
    startup/: startup_stm32f429x.s system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/Librarybuild/Debug/Exe/: Library.a
